#include "dal_ssd1306_font_internal.h"

/* MVP 子集：空格、0-9、A/D/E/H/I/L/O/P/R/S/T/W、!（共 24 字形）。
 * 构建选项 WINK_SSD1306_FONT=minimal 时链入，约 120 B Flash。 */

#define FONT_ENTRIES 24

static const uint8_t s_font[FONT_ENTRIES][DAL_SSD1306_FONT_GLYPH_BYTES] = {
    {0x00, 0x00, 0x00, 0x00, 0x00}, /*  0: space */
    {0x3E, 0x51, 0x49, 0x45, 0x3E}, /*  1: '0' */
    {0x00, 0x42, 0x7F, 0x40, 0x00}, /*  2: '1' */
    {0x42, 0x61, 0x51, 0x49, 0x46}, /*  3: '2' */
    {0x21, 0x41, 0x45, 0x4B, 0x31}, /*  4: '3' */
    {0x18, 0x14, 0x12, 0x7F, 0x10}, /*  5: '4' */
    {0x27, 0x45, 0x45, 0x45, 0x39}, /*  6: '5' */
    {0x3C, 0x4A, 0x49, 0x49, 0x30}, /*  7: '6' */
    {0x01, 0x71, 0x09, 0x05, 0x03}, /*  8: '7' */
    {0x36, 0x49, 0x49, 0x49, 0x36}, /*  9: '8' */
    {0x06, 0x49, 0x49, 0x29, 0x1E}, /* 10: '9' */
    {0x7E, 0x11, 0x11, 0x11, 0x7E}, /* 11: 'A' */
    {0x7F, 0x08, 0x08, 0x08, 0x7F}, /* 12: 'H' */
    {0x00, 0x41, 0x7F, 0x41, 0x00}, /* 13: 'I' */
    {0x3E, 0x41, 0x41, 0x41, 0x3E}, /* 14: 'O' */
    {0x7F, 0x09, 0x09, 0x09, 0x06}, /* 15: 'P' */
    {0x26, 0x49, 0x49, 0x49, 0x32}, /* 16: 'S' */
    {0x01, 0x01, 0x7F, 0x01, 0x01}, /* 17: 'T' */
    {0x2F, 0x48, 0x48, 0x48, 0x3F}, /* 18: 'W' */
    {0x00, 0x00, 0x5F, 0x00, 0x00}, /* 19: '!' */
    {0x7F, 0x49, 0x49, 0x49, 0x41}, /* 20: 'E' */
    {0x7F, 0x40, 0x40, 0x40, 0x40}, /* 21: 'L' */
    {0x7F, 0x09, 0x19, 0x29, 0x46}, /* 22: 'R' */
    {0x7F, 0x41, 0x41, 0x22, 0x1C}, /* 23: 'D' */
};

static int font_index(char c) {
    if (c == ' ') {
        return 0;
    }
    if (c >= '0' && c <= '9') {
        return 1 + (c - '0');
    }
    switch (c) {
        case 'A': return 11;
        case 'D': return 23;
        case 'E': return 20;
        case 'H': return 12;
        case 'I': return 13;
        case 'L': return 21;
        case 'O': return 14;
        case 'P': return 15;
        case 'R': return 22;
        case 'S': return 16;
        case 'T': return 17;
        case 'W': return 18;
        case '!': return 19;
        default:  return -1;
    }
}

const uint8_t *dal_ssd1306_font_glyph(char c) {
    int idx = font_index(c);
    if (idx < 0) {
        return s_font[0];
    }
    return s_font[idx];
}

// SPDX-License-Identifier: Apache-2.0
#include "dal_mono_oled_font_internal.h"

/* 5x7 compact font: space, digits 0-9, uppercase A-Z, exclamation mark (38 glyphs) */

#define FONT_SPACE  0
#define FONT_DIGIT0 1
#define FONT_LET_A  11
#define FONT_BANG   37
#define FONT_COUNT  38

static const uint8_t s_font[FONT_COUNT][DAL_MONO_OLED_FONT_GLYPH_BYTES] = {
    [FONT_SPACE]  = {0x00, 0x00, 0x00, 0x00, 0x00}, /* space */
    [FONT_DIGIT0] = {0x3E, 0x51, 0x49, 0x45, 0x3E}, /* '0' */
    [FONT_DIGIT0 + 1] = {0x00, 0x42, 0x7F, 0x40, 0x00}, /* '1' */
    [FONT_DIGIT0 + 2] = {0x42, 0x61, 0x51, 0x49, 0x46}, /* '2' */
    [FONT_DIGIT0 + 3] = {0x21, 0x41, 0x45, 0x4B, 0x31}, /* '3' */
    [FONT_DIGIT0 + 4] = {0x18, 0x14, 0x12, 0x7F, 0x10}, /* '4' */
    [FONT_DIGIT0 + 5] = {0x27, 0x45, 0x45, 0x45, 0x39}, /* '5' */
    [FONT_DIGIT0 + 6] = {0x3C, 0x4A, 0x49, 0x49, 0x30}, /* '6' */
    [FONT_DIGIT0 + 7] = {0x01, 0x71, 0x09, 0x05, 0x03}, /* '7' */
    [FONT_DIGIT0 + 8] = {0x36, 0x49, 0x49, 0x49, 0x36}, /* '8' */
    [FONT_DIGIT0 + 9] = {0x06, 0x49, 0x49, 0x29, 0x1E}, /* '9' */
    [FONT_LET_A]  = {0x7E, 0x11, 0x11, 0x11, 0x7E}, /* 'A' */
    [FONT_LET_A + 1]  = {0x7F, 0x49, 0x49, 0x49, 0x36}, /* 'B' */
    [FONT_LET_A + 2]  = {0x3E, 0x41, 0x41, 0x41, 0x22}, /* 'C' */
    [FONT_LET_A + 3]  = {0x7F, 0x41, 0x41, 0x22, 0x1C}, /* 'D' */
    [FONT_LET_A + 4]  = {0x7F, 0x49, 0x49, 0x49, 0x41}, /* 'E' */
    [FONT_LET_A + 5]  = {0x7F, 0x09, 0x09, 0x09, 0x01}, /* 'F' */
    [FONT_LET_A + 6]  = {0x3E, 0x41, 0x49, 0x49, 0x7A}, /* 'G' */
    [FONT_LET_A + 7]  = {0x7F, 0x08, 0x08, 0x08, 0x7F}, /* 'H' */
    [FONT_LET_A + 8]  = {0x00, 0x41, 0x7F, 0x41, 0x00}, /* 'I' */
    [FONT_LET_A + 9]  = {0x20, 0x40, 0x41, 0x3F, 0x01}, /* 'J' */
    [FONT_LET_A + 10] = {0x7F, 0x08, 0x14, 0x22, 0x41}, /* 'K' */
    [FONT_LET_A + 11] = {0x7F, 0x40, 0x40, 0x40, 0x40}, /* 'L' */
    [FONT_LET_A + 12] = {0x7F, 0x02, 0x0C, 0x02, 0x7F}, /* 'M' */
    [FONT_LET_A + 13] = {0x7F, 0x04, 0x08, 0x10, 0x7F}, /* 'N' */
    [FONT_LET_A + 14] = {0x3E, 0x41, 0x41, 0x41, 0x3E}, /* 'O' */
    [FONT_LET_A + 15] = {0x7F, 0x09, 0x09, 0x09, 0x06}, /* 'P' */
    [FONT_LET_A + 16] = {0x3E, 0x41, 0x51, 0x21, 0x5E}, /* 'Q' */
    [FONT_LET_A + 17] = {0x7F, 0x09, 0x19, 0x29, 0x46}, /* 'R' */
    [FONT_LET_A + 18] = {0x26, 0x49, 0x49, 0x49, 0x32}, /* 'S' */
    [FONT_LET_A + 19] = {0x01, 0x01, 0x7F, 0x01, 0x01}, /* 'T' */
    [FONT_LET_A + 20] = {0x3F, 0x40, 0x40, 0x40, 0x3F}, /* 'U' */
    [FONT_LET_A + 21] = {0x1F, 0x20, 0x40, 0x20, 0x1F}, /* 'V' */
    [FONT_LET_A + 22] = {0x3F, 0x40, 0x38, 0x40, 0x3F}, /* 'W' */
    [FONT_LET_A + 23] = {0x63, 0x14, 0x08, 0x14, 0x63}, /* 'X' */
    [FONT_LET_A + 24] = {0x07, 0x08, 0x70, 0x08, 0x07}, /* 'Y' */
    [FONT_LET_A + 25] = {0x61, 0x51, 0x49, 0x45, 0x43}, /* 'Z' */
    [FONT_BANG]   = {0x00, 0x00, 0x5F, 0x00, 0x00}, /* '!' */
};

static int font_index(char c) {
    if (c == ' ') {
        return FONT_SPACE;
    }
    if (c >= '0' && c <= '9') {
        return FONT_DIGIT0 + (c - '0');
    }
    if (c >= 'A' && c <= 'Z') {
        return FONT_LET_A + (c - 'A');
    }
    if (c >= 'a' && c <= 'z') {
        return FONT_LET_A + (c - 'a');
    }
    if (c == '!') {
        return FONT_BANG;
    }
    return -1;
}

const uint8_t *dal_mono_oled_font_glyph(char c) {
    int idx = font_index(c);
    if (idx < 0) {
        return s_font[FONT_SPACE];
    }
    return s_font[idx];
}
